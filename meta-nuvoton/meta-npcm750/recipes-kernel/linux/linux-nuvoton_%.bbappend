LINUX_VERSION_EXTENSION = "-npcm750"

#COMPATIBLE_MACHINE = "npcm750"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://defconfig"
           
